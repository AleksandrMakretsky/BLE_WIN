<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BlueDS.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\FirstPrj.ewp</path>
  </project>
  <batchBuild/>
</workspace>


