# IAR project BlueDS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\Boards\pca10056\blank\config; ..\MyNordic; ..\..\NordicSource\components; ..\..\NordicSource\components\boards; ..\..\NordicSource\components\drivers_nrf\nrf_soc_nosd; ..\..\NordicSource\components\drivers_nrf\usbd; ..\..\NordicSource\components\libraries\atomic; ..\..\NordicSource\components\libraries\atomic_fifo; ..\..\NordicSource\components\libraries\balloc; ..\..\NordicSource\components\libraries\bsp; ..\..\NordicSource\components\libraries\button; ..\..\NordicSource\components\libraries\cli; ..\..\NordicSource\components\libraries\cli\uart; ..\..\NordicSource\components\libraries\delay; ..\..\NordicSource\components\libraries\experimental_section_vars; ..\..\NordicSource\components\libraries\fifo; ..\..\NordicSource\components\libraries\hardfault; ..\..\NordicSource\components\libraries\hardfault\nrf52; ..\..\NordicSource\components\libraries\log; ..\..\NordicSource\components\libraries\log\src; ..\..\NordicSource\components\libraries\memobj; ..\..\NordicSource\components\libraries\mutex; ..\..\NordicSource\components\libraries\pwr_mgmt; ..\..\NordicSource\components\libraries\queue; ..\..\NordicSource\components\libraries\ringbuf; ..\..\NordicSource\components\libraries\scheduler; ..\..\NordicSource\components\libraries\strerror; ..\..\NordicSource\components\libraries\timer; ..\..\NordicSource\components\libraries\uart; ..\..\NordicSource\components\libraries\usbd; ..\..\NordicSource\components\libraries\usbd\class\cdc; ..\..\NordicSource\components\libraries\usbd\class\cdc\acm; ..\..\NordicSource\components\libraries\util; ..\..\NordicSource\components\toolchain\cmsis\include; ; ..\..\NordicSource\external\fnmatch; ..\..\NordicSource\external\fprintf; ..\..\NordicSource\external\segger_rtt; ..\..\NordicSource\external\utf_converter; ..\..\NordicSource\integration\nrfx; ..\..\NordicSource\integration\nrfx\legacy; ..\..\NordicSource\modules\nrfx; ..\..\NordicSource\modules\nrfx\drivers\include; ..\..\NordicSource\modules\nrfx\hal; ..\..\NordicSource\modules\nrfx\mdk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: bleSD140.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration nrf52840_xxaa (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ./: main.c
    ../../Boards/pca10056/blank/config/: sdk_config.h
  group Board Definition
    ../../NordicSource/components/boards/: boards.c
  group Board Support
    ../../NordicSource/components/libraries/bsp/: bsp.c bsp_cli.c
  group My Nordic
    ../MyNordic/: usb_wrapper.cpp
  group None
    ../../NordicSource/modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group nRF_Drivers
    ../../NordicSource/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_uart.c
    ../../NordicSource/components/drivers_nrf/usbd/: nrf_drv_usbd.c
    ../../NordicSource/components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../NordicSource/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_power_clock.c nrfx_uart.c nrfx_uarte.c
    ../../NordicSource/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../NordicSource/components/libraries/button/: app_button.c
    ../../NordicSource/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../NordicSource/components/libraries/fifo/: app_fifo.c
    ../../NordicSource/components/libraries/scheduler/: app_scheduler.c
    ../../NordicSource/components/libraries/timer/: app_timer.c
    ../../NordicSource/components/libraries/uart/: app_uart_fifo.c
    ../../NordicSource/components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../../NordicSource/components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../../NordicSource/external/fnmatch/: fnmatch.c
    ../../NordicSource/components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../NordicSource/components/libraries/hardfault/: hardfault_implementation.c
    ../../NordicSource/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../NordicSource/components/libraries/atomic/: nrf_atomic.c
    ../../NordicSource/components/libraries/balloc/: nrf_balloc.c
    ../../NordicSource/components/libraries/cli/: nrf_cli.c
    ../../NordicSource/components/libraries/cli/uart/: nrf_cli_uart.c
    ../../NordicSource/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../NordicSource/components/libraries/memobj/: nrf_memobj.c
    ../../NordicSource/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../NordicSource/components/libraries/queue/: nrf_queue.c
    ../../NordicSource/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../NordicSource/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../NordicSource/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../NordicSource/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../NordicSource/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group UTF8/UTF16 converter
    ../../NordicSource/external/utf_converter/: utf.c
